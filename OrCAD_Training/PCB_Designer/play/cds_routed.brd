# Allegro board cds_routed.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RD2: length 121.8
  TOP w0.127: U17.10 113.03,86.66 v1(112.52,86.16) ; U16.10 v1(113.03,77.11) ; U14.10 v1(88.27,76.38) ; v1(112.52,68.73) v1(88.27,68.73) ; U5.83 55.88,98.98 61.32,104.42 88.24,104.42 v1(88.27,104.39) ; U15.10 v1(88.27,101.78)
  BOTTOM w0.127: v1(88.27,68.73) v1(88.27,76.38) v1(88.27,101.78) v1(88.27,104.39) ; 112.52,77.11 v1(112.52,86.16) ; 112.52,77.11 v1(112.52,68.73) ; 112.52,77.11 v1(113.03,77.11)
RD3: length 110.6
  TOP w0.127: U15.7 v1(84.45,101.78) ; U5.84 54.61,95.38 56.13,93.85 69.09,93.85 71.83,91.11 v1(85.5,91.11) ; U16.7 v1(109.22,76.38) 108.03,77.57 91.82,77.57 90.04,75.79 90.04,73.71 85.17,73.71 84.45,74.42 U14.7 v1(84.45,76.38) ; U17.7 v1(109.22,89.28)
  BOTTOM w0.127: 84.45,93.14 85.47,93.14 85.72,92.89 85.72,91.34 v1(85.5,91.11) ; 84.45,93.14 83.95,92.63 83.95,76.89 v1(84.45,76.38) ; 84.45,93.14 v1(84.45,101.78) ; v1(109.22,89.28) v1(109.22,76.38)
RD4: length 137.6
  TOP w0.127: U13.26 84.45,96.22 v1(83.95,95.71) ; U12.26 109.22,70.48 108.23,69.49 85.27,69.49 v1(84.45,70.31) U10.26 ; U5.1 53.34,99.92 51.31,101.96 51.31,105.79 52.32,106.81 83.26,106.81 v1(83.95,107.49) 107.37,107.49 109.22,109.35 U11.26
  BOTTOM w0.127: v1(84.45,70.31) 83.69,71.07 83.69,95.45 v1(83.95,95.71) v1(83.95,107.49)
RD5: length 151.9
  TOP w0.127: v1(87.76,95.71) 88.27,96.22 U13.23 ; 87.76,72.47 v1(87.76,70.31) ; 87.76,72.47 88.01,72.47 88.27,72.21 U10.23 ; 87.76,72.47 87.76,72.72 87.5,72.97 83.95,72.97 83.95,69.49 84.2,69.24 111.79,69.24 113.03,70.48 U12.23 ; U11.23 113.03,108.36 110.49,105.82 v1(87.73,105.82) v1(52.07,105.82) ; U5.2 v1(52.07,97.89)
  BOTTOM w0.127: v1(87.73,105.82) 87.73,95.73 v1(87.76,95.71) v1(87.76,70.31) ; v1(52.07,97.89) v1(52.07,105.82)
RD6: length 143.8
  TOP w0.127: v1(89.31,68.02) 109.78,68.02 113.03,64.77 U12.10 ; 88.27,86.41 92.58,86.41 92.84,86.66 92.84,89.51 94.36,91.03 111,91.03 113.54,93.57 113.54,98.63 113.03,99.14 U11.10 ; 88.27,86.41 85.24,86.41 84.99,86.66 v1(84.99,89.81) 72.64,89.81 71.86,89.03 53.34,89.03 50.8,91.57 U5.3 ; 88.27,86.41 U13.10 ; U10.10 v1(88.27,63.68)
  BOTTOM w0.127: v1(88.27,63.68) 88.27,68.02 ; 88.27,68.02 v1(89.31,68.02) ; 88.27,68.02 86.49,69.8 86.49,89.59 85.75,90.32 85.5,90.32 v1(84.99,89.81)
RD7: length 151.9
  TOP w0.127: U10.7 v1(84.45,60.78) ; 85.22,93.42 v1(85.22,92.63) ; 85.22,93.42 80.9,93.42 78.87,95.45 78.87,98.09 77.85,99.11 57.91,99.11 57.66,98.86 57.66,95.22 55.37,95.22 55.37,97.41 55.12,97.66 54.1,97.66 54.1,95.48 53.85,95.22 52.83,95.22 52.83,98.07 52.5,98.4 49.89,98.4 49.53,98.04 U5.4 ; 85.22,93.42 85.22,98.37 104.65,98.37 104.9,98.12 104.9,95.94 105.16,95.68 108.2,95.68 108.71,96.19 108.71,98.63 109.22,99.14 U11.7 ; U12.7 v1(109.22,60.05) ; U13.7 v1(84.45,89.08)
  BOTTOM w0.127: v1(85.22,92.63) 84.45,91.87 v1(84.45,89.08) 86.23,87.3 86.23,60.78 ; v1(84.45,60.78) 86.23,60.78 ; 86.23,60.78 86.97,60.05 v1(109.22,60.05)
RDY: length 41
  TOP w0.127: U2.23 45.82,55.14 45.82,57.68 40.77,62.74 14.48,62.74 J1.50
RESET: length 44.4
  TOP w0.127: J1.53 24.41,68.58 26.95,71.12 26.95,86.56 31.19,90.8 U5.15
RWE: length 143.8
  TOP w0.127: U5.57 69.09,73.02 v1(69.72,73.66) ; 89.53,76.89 77.09,76.89 75.06,74.85 v1(75.06,73.74) ; 89.53,76.89 v1(89.53,76.38) U14.11 ; 89.53,76.89 89.53,77.57 89.79,77.83 113.36,77.83 114.3,76.89 ; U11.11 114.3,99.39 v1(114.81,98.88) ; U12.11 114.3,63.53 118.87,68.1 118.87,76.38 118.36,76.89 114.81,76.89 ; U16.11 114.3,76.89 ; 114.3,76.89 114.81,76.89 ; U17.11 114.3,88.57 v1(114.81,89.08) 114.81,76.89 ; v1(90.04,101.78) 89.53,101.27 U15.11 ; U13.11 v1(89.53,89.08) ; U10.11 89.53,63.17 v1(90.04,63.68)
  BOTTOM w0.127: v1(90.04,101.78) 90.04,89.08 ; 90.04,89.08 90.04,76.38 ; 90.04,89.08 v1(89.53,89.08) ; 90.04,76.38 v1(89.53,76.38) ; 90.04,76.38 v1(90.04,63.68) ; v1(69.72,73.66) 75.06,73.66 v1(75.06,73.74) ; v1(114.81,98.88) v1(114.81,89.08)
SEL: length 76.1
  TOP w0.127: v1(47.02,72.09) 47.02,87.68 41.35,93.34 U5.13
  BOTTOM w0.127: v1(47.02,72.09) 50.57,72.09 53.11,69.55 53.11,33.43 50.16,30.48 U2.14
V+12: length 227.3
  TOP w0.381: v1(101.09,20.32) U23.4 104.78,20.32 U20.7 ; v1(102.51,23.88) 102.34,24.05 7.29,24.05 6.02,25.32 6.02,91.54 7.04,92.56 11.28,92.56 J1.63 J1.64 ; v1(105.49,40) U19.4 v1(101.42,40)
  BOTTOM w0.381: v1(105.49,40) 105.49,38.66 107.31,36.83 ; v1(101.42,40) 102.51,38.91 102.51,27.3 ; 102.51,27.3 v1(102.51,23.88) 102.51,21.74 v1(101.09,20.32) 101.09,18.67 100.84,18.41 100.33,18.41 97.79,15.88 97.79,10.9 98.81,9.88 99.97,9.88 C28.1 ; 102.51,27.3 C25.1
VCLKA: length 82.6
  TOP w0.203: 71.35,42.52 58.78,42.52 48.92,52.37 48.92,59.99 41.91,67.01 U5.34 ; 71.35,42.52 71.35,30.68 72.82,29.21 U8.11 v1(76.28,29.21) ; 71.35,42.52 76.23,42.52 78.1,40.64 U18.11 ; U21.11 v1(76.28,20.32)
  BOTTOM w0.203: v1(76.28,20.32) v1(76.28,29.21)
VCLKC: length 89.4
  TOP w0.203: U9.11 v1(67.79,8.89)
  BOTTOM w0.203: v1(67.79,8.89) 67.79,62 65.25,64.54 60.22,64.54 51.69,73.08 43.48,73.08 R5.2
VD0: length 86.6
  TOP w0.127: U9.2 v1(59.87,19.05) ; U6.2 v1(62.69,55.88) 52.32,55.88 51.56,56.64 51.56,68.35 50.83,69.09 48.51,69.09 48.26,68.83 U5.39 ; U8.2 v1(61.39,39.37)
  BOTTOM w0.127: 59.87,21.59 59.87,37.85 v1(61.39,39.37) 61.39,54.58 v1(62.69,55.88) ; 59.87,21.59 v1(59.87,19.05) ; 59.87,21.59 R9.2
VD1: length 87
  TOP w0.127: v1(63.2,41.38) 65.79,41.38 66.09,41.07 66.09,39.55 64.64,38.1 U8.3 ; U6.3 v1(62.69,54.61) 51.82,54.61 49.53,56.9 U5.40 ; v1(54.48,19.05) 55.75,17.78 v1(62.69,17.78) U9.3
  BOTTOM w0.127: v1(62.69,17.78) 63.2,18.29 v1(63.2,41.38) 63.2,54.1 v1(62.69,54.61) ; R13.2 v1(54.48,19.05)
VD2: length 96.7
  TOP w0.127: U5.41 50.8,56.13 51.56,55.37 65.05,55.37 65.58,54.84 v1(65.58,54.33) 64.59,53.34 U6.4 ; v1(64.57,28.22) 62.74,28.22 61.72,29.24 61.72,34.92 63.63,36.83 U8.4 ; v1(49.15,16.51) v1(62.69,16.51) U9.4
  BOTTOM w0.127: v1(65.58,54.33) 64.57,53.31 v1(64.57,28.22) 64.57,17.63 63.45,16.51 v1(62.69,16.51) ; R8.2 v1(49.15,16.51)
VD3: length 85.9
  TOP w0.127: U6.5 v1(65.58,52.07) 66.09,52.58 66.09,55.63 65.07,56.64 54.61,56.64 52.07,59.18 U5.42 ; U8.5 v1(65.76,35.56) ; U9.5 v1(62.69,15.24) 56.01,15.24 v1(54.74,13.97)
  BOTTOM w0.127: 65.07,35.56 65.07,17.63 v1(62.69,15.24) ; 65.07,35.56 65.07,51.56 v1(65.58,52.07) ; 65.07,35.56 v1(65.76,35.56) ; R12.2 v1(54.74,13.97)
VD4: length 90.6
  TOP w0.127: U5.43 53.34,60.96 55.88,58.42 64.57,58.42 66.34,56.64 v1(66.34,51.03) 66.12,50.8 U6.6 ; U8.6 v1(65.58,34.29) ; U9.6 v1(65.58,13.97)
  BOTTOM w0.127: R7.2 60.66,11.43 62.43,9.65 63.04,9.65 65.58,12.19 v1(65.58,13.97) v1(65.58,34.29) 66.34,35.05 v1(66.34,51.03)
VD5: length 100.9
  TOP w0.127: U8.7 65.15,33.02 66.27,34.14 66.27,36.32 65.25,37.34 v1(61.93,37.34) ; v1(61.93,49.53) U6.7 65.58,49.53 66.85,50.8 66.85,58.42 65.84,59.44 56.13,59.44 54.61,60.96 U5.44 ; U9.7 v1(60.38,12.7)
  BOTTOM w0.127: R11.2 47.12,9.78 47.12,12.45 47.37,12.7 v1(60.38,12.7) 60.38,35.79 v1(61.93,37.34) v1(61.93,49.53)
VD6: length 99.8
  TOP w0.127: v1(61.39,6.35) 61.39,9.65 63.17,11.43 U9.8 ; U5.45 55.88,62.74 58.42,60.2 65.58,60.2 67.11,58.67 67.11,48.29 v1(67.08,48.26) U6.8 ; U8.8 v1(67.08,31.75)
  BOTTOM w0.127: v1(67.08,48.26) v1(67.08,31.75) 67.08,9.5 63.93,6.35 v1(61.39,6.35) R6.2
VD7: length 94.8
  TOP w0.127: U9.9 v1(62.64,10.16) v1(62.64,3.81) ; U5.46 v1(57.15,63.25) ; U8.9 64.64,30.48 65.61,29.51 65.61,28.35 64.72,27.46 v1(63.7,27.46) ; v1(63.7,44.98) 63.2,44.98 62.66,45.52 62.66,46.91 62.74,46.99 U6.9
  BOTTOM w0.127: v1(57.15,63.25) 59.69,63.25 63.7,59.23 v1(63.7,44.98) v1(63.7,27.46) 63.7,17.83 63.14,17.27 62.64,17.27 61.87,16.51 61.87,10.92 v1(62.64,10.16) ; R10.2 v1(62.64,3.81)
VREF: length 34.9
  TOP w0.127: L5.1 113.18,3.96 102.08,3.96 R14.1
  BOTTOM w0.127: L5.1 115.16,5.94 115.16,23.27 L3.1
WAIT: length 29.5
  TOP w0.127: U5.33 36.75,63.5 J1.51
WSTAT: length 31.5
  TOP w0.127: U5.56 v1(69.82,71.75) ; U6.11 v1(69.82,45.72)
  BOTTOM w0.127: v1(69.82,71.75) v1(69.82,45.72)
N00036: length 47.1
  TOP w0.127: 89.48,36.7 89.48,38.1 ; 89.48,36.7 99.19,36.7 101.47,34.42 v1(101.47,33.02) 101.47,30.48 104.01,27.94 L4.2 ; 89.48,36.7 89.48,36.45 89.1,36.07 87.1,36.07 86.79,35.76 86.79,35.26 87.76,34.29 U18.5 ; 89.48,38.1 98.86,38.1 99.11,38.35 99.11,39.29 98.4,40 U19.5 ; 89.48,38.1 U18.8
  BOTTOM w0.127: R16.1 v1(101.47,33.02) 101.47,31.62 R15.1
N00038: length 29.2
  TOP w0.127: v1(83.82,34.49) 85.29,33.02 U18.4 90.75,33.02 93.29,30.48 93.29,27.94 96.47,24.77 L3.2
  BOTTOM w0.127: C24.1 v1(83.82,34.49)
N00044: length 29.3
  TOP w0.127: U20.2 112.8,15.34 114.78,17.32 114.78,28.04 114.02,28.8 110.26,28.8 U19.1
N00060: length 37.5
  TOP w0.127: U18.6 90.81,35.56 99.97,26.39 110.36,26.39 114.53,22.23 114.53,18.64 U20.3
N14843: length 3.2
  BOTTOM w0.127: C13.1 R12.1
N14849: length 3.2
  BOTTOM w0.127: C9.1 R8.1
N14853: length 3.2
  BOTTOM w0.127: C14.1 R13.1
N14855: length 3.2
  BOTTOM w0.127: R9.1 C10.1
N15143: length 3.2
  BOTTOM w0.127: C11.1 R10.1
N15151: length 3.2
  BOTTOM w0.127: C7.1 R6.1
N15155: length 3.2
  BOTTOM w0.127: C12.1 R11.1
N15161: length 3.2
  BOTTOM w0.127: C8.1 R7.1
N58063: length 5.7
  TOP w0.127: U8.19 U18.12
N58118: length 5.7
  TOP w0.127: U8.18 U18.13
N58173: length 5.7
  TOP w0.127: U8.17 U18.14
N58228: length 5.7
  TOP w0.127: U8.16 U18.15
N58283: length 5.7
  TOP w0.127: U8.15 U18.16
N58338: length 5.7
  TOP w0.127: U8.14 U18.17
N58393: length 5.7
  TOP w0.127: U8.13 U18.18
N58448: length 5.7
  TOP w0.127: U8.12 U18.19
N58834: length 6.4
  TOP w0.127: U9.19 U21.12
N58889: length 6.4
  TOP w0.127: U9.18 U21.13
N58944: length 6.4
  TOP w0.127: U9.17 U21.14
N58999: length 6.4
  TOP w0.127: U9.16 U21.15
N59054: length 6.4
  TOP w0.127: U9.15 U21.16
N59109: length 6.4
  TOP w0.127: U9.14 U21.17
N59164: length 6.4
  TOP w0.127: U9.13 U21.18
N59219: length 6.4
  TOP w0.127: U9.12 U21.19
N282866: length 5.3
  TOP w0.127: U19.8 v1(96.44,36.2)
  BOTTOM w0.127: v1(96.44,36.2) 96.44,34.62 R16.2
N282912: length 9.9
  TOP w0.127: U19.2 v1(101.32,37.46)
  BOTTOM w0.127: v1(101.32,37.46) 99.19,35.33 99.19,31.62 R15.2
N409523: length 4.9
  TOP w0.127: U5.37 v1(45.72,68.83)
  BOTTOM w0.127: R5.1 45.72,70.48 v1(45.72,68.83)

## Copper pours and planes (outline as drawn)
GND on GND: 2.03,107.82 22.99,107.82 23.11,107.95 23.11,111.89 24,112.78 124.08,112.78 124.08,1.52 23.37,1.52 22.99,1.91 22.99,6.48 22.86,6.6 1.78,6.6 1.4,6.99 1.4,107.19 ; 2 cut-outs
VCC on VCC: 1.9,107.7 23.11,107.7 23.11,112.52 23.37,112.78 123.95,112.78 124.33,112.39 124.33,1.91 123.82,1.4 23.62,1.4 22.99,2.03 22.99,6.48 22.86,6.6 1.9,6.6 1.4,7.11 1.4,107.19 ; 2 cut-outs
